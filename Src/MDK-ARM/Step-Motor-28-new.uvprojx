# Keil uVision project Step-Motor-28-new.uvprojx, settings and files
target Step-Motor-28-new (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F103CB APEXMIC
  pack: APEXMIC.APM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Step-Motor-28-new +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Drivers\Board;..\Drivers\Peripheral;..\Motor_control;..\User;..\Communication
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f103xb.s
  group Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers_HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers_CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers_Peripheral
    ../Drivers/Peripheral/: w25q128.c mt6816.c TB67H450.c
  group Motor_control
    ../Motor_control/: sin_form.c motor_control.c
  group Communication
    ../Communication/: communication.c
  group User
    ../User/: main_thread.c main_thread_it.c
software components: CMSIS:CORE 5.1.1
